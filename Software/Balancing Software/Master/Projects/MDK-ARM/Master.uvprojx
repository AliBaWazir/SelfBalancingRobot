# Keil uVision project Master.uvprojx, settings and files
target STM32F407VGT6 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F405RG
  c flags: Optim=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,MPU9250,USE_DMP,MPL_LOG_NDEBUG=0,EMPL,EMPL_TARGET_STM32F4,ARM_MATH_CM4,__FPU_PRESENT=1,HSE_VALUE=16000000
  c misc: --wchar32 --C99
  c include: ..\..\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\eMPL\driver\eMPL;..\..\Drivers\eMPL\driver\include;..\..\Drivers\eMPL\driver\STM32F4;..\..\Drivers\eMPL\eMPL-hal;..\..\Drivers\eMPL\mllite;..\..\Drivers\eMPL\mpl;..\..\..\matlab\Model\model2\R2015a\simulink\include;..\..\..\matlab\Model\model2\otherFiles;..\..\Src;..\..\..\..\..\..\..\Downloads\PROJECT-03-STM32F4xx_PID\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\..\..\matlab\Model\try3\discrete_PID_ert_rtw;..\..\Drivers\STM32F4xx_HAL_Driver\Src
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Application/User
    ../../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c stm32f4xx_empl_drv.c arduino32.cpp AccelStepper.cpp stepper_interface.cpp defines.h tm_stm32_gpio.c tm_stm32_rcc.c tm_stm32_delay.c application_main.c tm_stm32_buffer.c tm_stm32_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32_hal_legacy.h tm_stm32_button.c application_pid.c logging.c buttons.c leds.c coms.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../stm32f429-master/stm32f429-master/00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/DSP_Lib/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_reset_f32.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/eMD
    ../../Drivers/eMPL/eMPL-hal/: eMPL_outputs.c
    ../../Drivers/eMPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../../Drivers/eMPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../Drivers/eMPL/mpl/: libmpllib.a
    ../../Drivers/eMPL/driver/STM32F4/: log_stm32.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
